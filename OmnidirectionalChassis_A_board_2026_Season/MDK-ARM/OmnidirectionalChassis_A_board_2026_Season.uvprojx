# Keil uVision project OmnidirectionalChassis_A_board_2026_Season.uvprojx, settings and files
target OmnidirectionalChassis_A_board_2026_Season (6220000::V6.22::ARMCLANG)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: OmnidirectionalChassis_A_board_2026_Season +hex
  c flags: OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F427xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;./User;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F
  asm include: ../Core/Inc;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f427xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c can.c dma.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group User\Low\ControllerAreaNetwork
    ./User/Low/ControllerAreaNetwork/: UserCan.cpp UserCan.hpp
  group User\Low\MotorLibrary
    ./User/Low/MotorLibrary/: BenMo.cpp BenMo.hpp DaMiao.cpp DaMiao.hpp DJIMotor.cpp DJIMotor.hpp LingKongMortor.cpp LingKongMotor.hpp
  group User\Low\UniversalAsynchronousTransceiver
    ./User/Low/UniversalAsynchronousTransceiver/: IMU.cpp IMU.hpp SerialCallback.cpp SerialCallback.hpp Clicker.cpp Clicker.hpp
  group User\Middle\MotorControl
    ./User/Middle/MotorControl/: ADRC.cpp ADRC.hpp Feedback.cpp Feedback.hpp Invoke.cpp Invoke.hpp PID.cpp PID.hpp
  group User\Middle\Gimbal
    ./User/Middle/Gimbal/: Towards.cpp Towards.hpp
  group User\Middle\Communication
    ./User/Middle/Communication/: BoardCommunication_AtoC.cpp BoardCommunication_AtoC.hpp
  group User\Middle\LaunchMechanism
    ./User/Middle/LaunchMechanism/: Dial.cpp Dial.hpp FrictionWheel.cpp FrictionWheel.hpp
  group User\Middle\Vision
    ./User/Middle/Vision/: Visual.cpp Visual.hpp
  group User\High\Task
    ./User/High/Task/: TaskProcess.cpp TaskProcess.hpp
  group User\Middle\RemoteControl
    ./User/Middle/RemoteControl/: RemoteOperation.cpp RemoteOperation.hpp
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group User\Middle\Buzzer
    ./User/Middle/Buzzer/: buzzer.cpp buzzer.hpp
software components: CMSIS:CORE 6.1.0
